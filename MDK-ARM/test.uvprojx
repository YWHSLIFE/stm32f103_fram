# Keil uVision project test.uvprojx, settings and files
target test (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: test +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c include: ../Core/Inc;../RT-Thread;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/components/finsh/;../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/include/;..\Hardware\LED;..\Hardware\OLED
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c spi.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c stm32f1xx_hal_spi.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group Middlewares/RT-Thread/RTOS/shell
    ../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/components/finsh/: shell.c cmd.c msh.c
  group Middlewares/RT-Thread/RTOS/kernel
    ../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/libcpu/arm/cortex-m3/: context_rvds.S cpuport.c
    ../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/bsp/: board.c
    ../Middlewares/Third_Party/RealThread_RTOS_RT-Thread/src/: clock.c components.c idle.c ipc.c irq.c kservice.c mem.c object.c scheduler.c thread.c timer.c
  group Hardware
    ../Hardware/LED/: led.c
    ../Hardware/OLED/: oled.c oled_g.c oled_port.c
software components: CMSIS:CORE 4.3.0
